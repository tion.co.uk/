Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-09-03T14:40:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 03 14:40:25 2024 * Host: NCL-PI02 * Database: C:\Users\connm\AppData\Local\Temp\9833518c-9ec3-4f28-9a05-c6bece05ca63\62694d6e-db21-4ebc-a0a1-e6e54fed112b\ifc * Database version: 5507 * Database creation date: Tue Sep 03 14:40:21 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 03 14:40:24 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 03 14:40:24 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcDistributionPort, Port_369001
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: NBS_TionGlobalLtd_GnrlPrpseFumeCpbrds_WetScrubberFumeCupboard:PPFC1200-WS–StandardModelConstantAirVolume, NBS_TionGlobalLtd_GnrlPrpseFumeCpbrds_WetScrubberFumeCupboard:PPFC1200-WS–StandardModelConstantAirVolume:369001
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_60_65_31_33 (Uniclass2015); Material: NBS_Tion_Turquoise, NBS_Tion_Polypropylene_White (3), NBS_Tion_StainlessSteel, NBS_Tion_Black (6), NBS_Glass_Single
Type - IFC - IfcExportAs: IfcElectricApplianceType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_65_31_33:General-purpose fume cupboards; Color: White; Finish: n/a; Material: Polypropylene; Shape: Rectangle; Size: 1200 x 980 x 2370 mm; WarrantyDescription: One year; CodePerformance: EN 14175, ASHRAE 110-1995; Constituents: n/a; Description: Corrosion-proof fume cupboards for heavy chemicals. Suitable for acid digestion using hydrofluoric acid (HF).; DurationUnit: year; ExpectedLife: n/a; Features: Polypropylene construction, Integrated scrubber; Grade: n/a; Manufacturer: support@tion.co.uk; ModelNumber: PPFC1200-WS; ModelReference: Wet Scrubber Fume Cupboard; Name: General-purposeFumeCupboards_WetScrubberFumeCupboard_PPFC1200-WS–StandardModelConstantAirVolume_TionGlobalLtd; NominalHeight: 2370 mm; NominalLength: 1200 mm; NominalWidth: 980 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_TionGlobalLtd_General-purposeFumeCupboards_WetScrubberFumeCupboard_PPFC1200-WS–StandardModelConstantAirVolume; ManufacturerName: Tion Global Ltd; ManufacturerURL: https://www.tion.co.uk; ProductInformation: https://source.thenbs.com/product/-/b7b6d78c-1941-46a3-8165-8efe068f29c9/9e964c84-6b1e-4597-b54d-1a8ddd7d9579; Uniclass2015Code: Pr_60_65_31_33; Uniclass2015Title: General-purpose fume cupboards; Uniclass2015Version: Products v1.35; Version: 2
Type - NBS_Data - Standard: To EN 14175; Arrangement: Free standing unit; SpecialRequirements: Acid-based processes; ExtractAirFaceVelocity: 0.5 ±0.1 m/s (100 ±20 FPM); ExtractAirOperation: Continuous; Materials: Polypropylene; SashSashArrangement: Horizontal; SashOperation: Manual; SashMaximumOperationalSashOpening: 500 mm; DimensionsOverallDepth: 980 mm; DimensionsOverallWidth: 1200 mm; LightingLightingType: LED lighting; LightingIlluminanceAtWorkSurfaceMinimum: 800 lx; ServicesWaterSinkUnit: Not required,Required; ServicesWaterWaterSupply: Not required,Cold water supply,Hot water supply,Reverse osmosis water supply,Demineralized water supply; ElectricityPowerRequirements: 110 V, 50/60 Hz, single-phase,220 V, 50/60 Hz, single-phase; GasOutlets: Not required,Nitrogen; AirflowIndicatorWithAudibleAndVisualAlarms: Constant airflow monitoring and display with visual alarm on screen and integrated internal red light alarm system; ControlsControllerType: Touch screen control panel, 7-inch; ControlsControlModes: Eco mode; Accessories: Not required,Auto-dosing,Glove apertures,Height adjustable stands,Multisash,PH monitoring,Partitions,Shelves,Storage,Sumps,Vacuum tap; Material: Polypropylene; ExpectedLife: n/a; Worksurface: HPL,Ceramic,Epoxy,Polypropylene,Stainless steel
Material: NBS_Tion_Black, NBS_Tion_Polypropylene_White, NBS_Glass_Single
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
