Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-09-03T14:38:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 03 14:38:33 2024 * Host: NCL-PI02 * Database: C:\Users\connm\AppData\Local\Temp\9833518c-9ec3-4f28-9a05-c6bece05ca63\42ffc45f-5ede-4856-8f09-bfb4ecdc738d\ifc * Database version: 5507 * Database creation date: Tue Sep 03 14:38:29 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 03 14:38:33 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 03 14:38:33 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcDistributionPort, Port_369001
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: NBS_TionGlobalLtd_GnrlPrpseFumeCpbrds_WalkInFumeCupboardDucted:WI1200-D–ProModelVariableAirVolume, NBS_TionGlobalLtd_GnrlPrpseFumeCpbrds_WalkInFumeCupboardDucted:WI1200-D–ProModelVariableAirVolume:369001
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_60_65_31_33 (Uniclass2015); Material: NBS_Tion_Polypropylene_White (5), NBS_Tion_StainlessSteel, NBS_Tion_Black (5), NBS_Tion_Turquoise, NBS_Glass_Single (2)
Type - IFC - IfcExportAs: IfcElectricApplianceType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_65_31_33:General-purpose fume cupboards; Color: White; Finish: n/a; Material: Polypropylene; Shape: Rectangle; Size: 1200 x 930 x 2320 mm; WarrantyDescription: One year; CodePerformance: EN 14175-2, ASHRAE 110-1995; Constituents: n/a; Description: Ducted ventilated enclosures for housing large equipment and processes.; DurationUnit: year; ExpectedLife: n/a; Features: 100% Polypropylene carcass, Customisable dimensions; Grade: n/a; Manufacturer: support@tion.co.uk; ModelNumber: WI1200-D; ModelReference: Walk-In Fume Cupboard, Ducted; Name: General-purposeFumeCupboards_Walk-InFumeCupboardDucted_WI1200-D–ProModelVariableAirVolume_TionGlobalLtd; NominalHeight: 2320 mm; NominalLength: 1200 mm; NominalWidth: 930 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_TionGlobalLtd_General-purposeFumeCupboards_Walk-InFumeCupboardDucted_WI1200-D–ProModelVariableAirVolume; ManufacturerName: Tion Global Ltd; ManufacturerURL: https://www.tion.co.uk; ProductInformation: https://source.thenbs.com/product/-/867c582a-70e2-484f-a556-3d61974d0265/9dede6a2-3971-4eb3-9e21-f35d9a80558e; Uniclass2015Code: Pr_60_65_31_33; Uniclass2015Title: General-purpose fume cupboards; Uniclass2015Version: Products v1.35; Version: 4
Type - NBS_Data - Standard: To EN 14175; Arrangement: Walk-in; ExtractAirFaceVelocity: 0.5 ±0.1 m/s (100 ±20 FPM); ExtractAirOperation: Facility to vary extract volume flow rate; Materials: Polypropylene; SashSashArrangement: Horizontal sliding doors,Vertical single sash (weighted),Vertical dual sash (weighted); SashOperation: Manual,Powered, automatic; DimensionsOverallDepth: 930 mm; DimensionsOverallWidth: 1200 mm; LightingLightingType: LED lighting; LightingIlluminanceAtWorkSurfaceMinimum: 800 lx; ServicesWaterSinkUnit: Not required,Rubber sink,Polypropylene sink; ServicesWaterWaterSupply: Not required,Cold water supply,Hot water supply,Reverse osmosis water supply,Demineralized water supply; ElectricityPowerRequirements: 110 V, 50/60 Hz, single-phase,220 V, 50/60 Hz, single-phase; ElectricityElectricalSocketOutlets: Four; ElectricityLocation: Sockets on front face of fume cupboard; GasOutlets: Not required,Nitrogen,Argon,Hydrogen,Vacuum,Compressed Air,Other; AirflowIndicatorWithAudibleAndVisualAlarms: Constant airflow monitoring and display with visual alarm on screen and integrated internal red light alarm system; ControlsControllerType: Touch screen control panel, 9-inch; ControlsControlModes: Night setback mode, Eco mode; Accessories: Not required,Centrifugal fans,Fold out benchtops,Glove apertures,Multisash,Partitions,Shelves,Sumps,Vacuum tap; Material: Polypropylene; ExpectedLife: n/a; SafetyDevices: Not required,Co2/ powder fire suppression,External interlock emergency stop; ServicesWaterDrainage: Not required,200 mm side well (drip cup),Other; Lining: Polypropylene,Stainless steel,PPS,Trespa; Cover: 304 stainless steel bund cover, grated design,304 stainless steel bund cover, sheet design; Flooring: Polypropylene,Stainless steel,Electro static dissipative (ESD)
Material: NBS_Glass_Single, NBS_Tion_Polypropylene_White, NBS_Tion_StainlessSteel, NBS_Tion_Black
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
