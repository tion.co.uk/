Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-09-03T14:37:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 03 14:37:22 2024 * Host: NCL-PI02 * Database: C:\Users\connm\AppData\Local\Temp\9833518c-9ec3-4f28-9a05-c6bece05ca63\2c02c676-5e47-4f9e-89cd-1b9e4f1fa9be\ifc * Database version: 5507 * Database creation date: Tue Sep 03 14:37:18 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 03 14:37:22 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 03 14:37:22 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcDistributionPort, Port_369001
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: NBS_TionGlobalLtd_GnrlPrpseFumeCpbrds_DuctedFumeCupboard:PPFC120–ProModelVariableAirVolume, NBS_TionGlobalLtd_GnrlPrpseFumeCpbrds_DuctedFumeCupboard:PPFC120–ProModelVariableAirVolume:369001
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_60_65_31_33 (Uniclass2015); Material: NBS_Tion_Black (5), NBS_Tion_Polypropylene_White (3), NBS_Tion_Turquoise, NBS_Tion_StainlessSteel, NBS_Glass_Single
Type - IFC - IfcExportAs: IfcElectricApplianceType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_65_31_33:General-purpose fume cupboards; Color: White; Finish: n/a; Material: Polypropylene; Shape: Rectangle; Size: 1200 x 830 x 2320 mm; WarrantyDescription: One year; CodePerformance: EN 14175, ASHRAE 110-1995; Constituents: n/a; Description: A metal-free, corrosion-proof fume extraction solution designed for chemical-intensive applications.; DurationUnit: year; ExpectedLife: n/a; Features: 100% Polypropylene carcass, Customisable dimensions; Grade: n/a; Manufacturer: support@tion.co.uk; ModelNumber: PPFC120; ModelReference: Ducted Fume Cupboard; Name: General-purposeFumeCupboards_DuctedFumeCupboard_PPFC120–ProModelVariableAirVolume_TionGlobalLtd; NominalHeight: 2320 mm; NominalLength: 1200 mm; NominalWidth: 830 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_TionGlobalLtd_General-purposeFumeCupboards_DuctedFumeCupboard_PPFC120–ProModelVariableAirVolume; ManufacturerName: Tion Global Ltd; ManufacturerURL: https://www.tion.co.uk; ProductInformation: https://source.thenbs.com/product/-/986fbdc1-fb95-46f2-b81b-bbed3f904796/c3047ad6-82e3-434e-b48e-75a43b79a29b; Uniclass2015Code: Pr_60_65_31_33; Uniclass2015Title: General-purpose fume cupboards; Uniclass2015Version: Products v1.35; Version: 3
Type - NBS_Data - Standard: To EN 14175; Arrangement: Free standing unit; SpecialRequirements: Acid-based processes; ExtractAirFaceVelocity: 0.5 ±0.1 m/s (100 ±20 FPM); ExtractAirOperation: Facility to vary extract volume flow rate; Materials: Polypropylene; SashSashArrangement: Horizontal; SashOperation: Powered, automatic; SashMaximumOperationalSashOpening: 500 mm; DimensionsOverallDepth: 830 mm,Bespoke; DimensionsOverallWidth: 1200 mm; LightingLightingType: LED lighting; LightingIlluminanceAtWorkSurfaceMinimum: 800 lx; ServicesWaterSinkUnit: Not required,Required; ServicesWaterWaterSupply: Not required,Cold water supply,Hot water supply,Reverse osmosis water supply,Demineralized water supply; ElectricityPowerRequirements: 110 V, 50/60 Hz, single-phase,220 V, 50/60 Hz, single-phase; ElectricityElectricalSocketOutlets: Four; ElectricityLocation: Sockets on front face of fume cupboard; GasOutlets: Not required,Nitrogen; AirflowIndicatorWithAudibleAndVisualAlarms: Constant airflow monitoring and display with visual alarm on screen and integrated internal red light alarm system; ControlsControllerType: Touch screen control panel, 9-inch; ControlsControlModes: Eco mode, Night setback mode (pro only); Accessories: Not required,Centrifugal fans,Glove apertures,Multisash,Partitions,Shelves,Sumps,Vacuum tap; Material: Polypropylene; ExpectedLife: n/a; Worksurface: Polypropylene,Stainless steel,Ceramic,Epoxy,Trespa; SafetyDevices: Not required,Co2/powder fire supression,External interlock emergency stop
Material: NBS_Tion_StainlessSteel, NBS_Tion_Black, NBS_Tion_Polypropylene_White, NBS_Glass_Single
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
