Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-09-03T14:41:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 03 14:41:02 2024 * Host: NCL-PI02 * Database: C:\Users\connm\AppData\Local\Temp\9833518c-9ec3-4f28-9a05-c6bece05ca63\2df49613-00a4-4e61-892f-149dd1b2c39f\ifc * Database version: 5507 * Database creation date: Tue Sep 03 14:40:58 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 03 14:41:02 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 03 14:41:02 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcDistributionPort, Port_369001
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: NBS_TionGlobalLtd_RcrcltryFltrtnFumeCpbrds_WalkInFumeCupboardRecirculating:WI1200-R–ProModelVariableAirVolume, NBS_TionGlobalLtd_RcrcltryFltrtnFumeCpbrds_WalkInFumeCupboardRecirculating:WI1200-R–ProModelVariableAirVolume:369001
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_60_65_31_71 (Uniclass2015); Material: NBS_Glass_Single (2), NBS_Tion_Black (5), NBS_Tion_StainlessSteel, NBS_Tion_Polypropylene_White (5), NBS_Tion_Turquoise
Type - IFC - IfcExportAs: IfcElectricApplianceType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_65_31_71:Recirculatory filtration fume cupboards; Color: White; Finish: Other; Material: Polypropylene; Shape: Rectangle; Size: 1200 x 930 x 2420 mm; WarrantyDescription: One year; CodePerformance: EN 14175, ASHRAE 110-1995; Constituents: n/a; Description: Recirculating ventilated enclosures for housing large equipment.; DurationUnit: year; ExpectedLife: Ten year; Features: 100% Polypropylene carcass, Customisable dimensions; Grade: n/a; Manufacturer: support@tion.co.uk; ModelNumber: WI1200-R; ModelReference: Walk-In Fume Cupboard, Recirculating; Name: RecirculatoryFiltrationFumeCupboards_Walk-InFumeCupboardRecirculating_WI1200-R–ProModelVariableAirVolume_TionGlobalLtd; NominalHeight: 2420 mm; NominalLength: 1200 mm; NominalWidth: 930 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_TionGlobalLtd_RecirculatoryFiltrationFumeCupboards_Walk-InFumeCupboardRecirculating_WI1200-R–ProModelVariableAirVolume; ManufacturerName: Tion Global Ltd; ManufacturerURL: https://www.tion.co.uk; ProductInformation: https://source.thenbs.com/product/-/3da9f368-bb8c-45a9-9a63-6f0298f3073d/76eb82bb-51e2-4339-969a-3baef887c838; Uniclass2015Code: Pr_60_65_31_71; Uniclass2015Title: Recirculatory filtration fume cupboards; Uniclass2015Version: Products v1.35; Version: 3
Type - NBS_Data - Standard: To EN 14175; Arrangement: Fixed; Materials: Polypropylene; SashSashArrangement: Horizontal sliding doors,Vertical single sash (weighted),Vertical dual sash (weighted); SashOperation: Manual,Powered, automatic; DimensionsOverallDepth: 930 mm; DimensionsOverallWidth: 1200 mm; LightingLightingType: LED lighting; LightingIlluminanceAtWorkSurfaceMinimum: 800 lx; AirflowIndicatorWithAudibleAndVisualAlarms: Constant airflow monitoring and display with visual alarm on screen and integrated internal red light alarm system; Accessories: Not required,Centrifugal fans,Fold out benchtops,Glove apertures,Multisash,Partitions,Shelves,Sumps,Vacuum tap,Gas taps; Material: Polypropylene; ExpectedLife: Ten year; SafetyDevices: Not required,Co2/ powder fire suppression,External interlock emergency stop; Lining: Polypropylene,Stainless steel,PPS,Trespa; Cover: 304 stainless steel bund cover, grated design,304 stainless steel bund cover, sheet design; Flooring: Polypropylene,Stainless steel,Electro static dissipative (ESD); Controls: Touch screen control panel, 9-inch; SoundPowerLevel: <60 dB; Filters: Gas and vapour,Particulate, HEPA,Particulate, ULPA; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Germany
Material: NBS_Glass_Single, NBS_Tion_Polypropylene_White, NBS_Tion_StainlessSteel, NBS_Tion_Black
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
